# IAR project L152_bootloader.ewp, settings and files
configuration L152_bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RB ST STM32L152RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L152_bootloader.bin
  ILINK.IlinkOutputFile: L152_bootloader.out
  ILINK.IlinkIcfFile: stm32l152xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l152xb.s
  group Application/User/Core
    ../Core/Src/: bootloader_app.c flash_io.c flash_test.c gpio.c main.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c usart.c
  group Application/User/inc
    ../Core/Inc/: bootloader_app.h flash_io.h flash_test.h gpio.h main.h spi.h stm32l1xx_hal_conf.h stm32l1xx_it.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_uart.c
